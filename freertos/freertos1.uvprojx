# Keil uVision project freertos1.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: MKW41Z512xxx4 NXP
  pack: Keil.Kinetis_KWxx_DFP.1.7.0
  cpu: IRAM(0x1FFF8000,0x00020000) IROM(0x00000000,0x00080000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: freertos1
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c misc: --show_cmdline
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x1fff8000 size 0x20000
  group Source Group 1
    ./: main.c
target RAM (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: MKW41Z512xxx4 NXP
  pack: Keil.Kinetis_KWxx_DFP.1.7.0
  cpu: as above
  output: freertos1
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c misc: --show_cmdline
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x1fff8000 size 0x20000
target MTB (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: MKW41Z512xxx4 NXP
  pack: Keil.Kinetis_KWxx_DFP.1.7.0
  cpu: as above
  output: freertos1
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: CLOCK_SETUP=1
  c misc: --show_cmdline
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
software components: RTOS:Config 9.0.0, RTOS:Core 9.0.0, RTOS:Coroutines 9.0.0, RTOS:Event Groups 9.0.0, RTOS:Heap 9.0.0, RTOS:Timers 9.0.0, CMSIS:CORE 5.0.2, Compiler:Event Recorder 1.1.0, Board Support:Buttons 1.0.0, Board Support:LED 1.0.0, Device:Startup 1.0.0
